# Keil uVision project Blynk.uvproj, settings and files
target Blynk (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Blynk
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c UART.c Blynk.c ST7735.c Timer2.c Timer3.c esp8266.c PortF.c PWM.c fixed.c clock.c bitmaps.h clock.h PWM.h fixed.h ADCSWTrigger.c ADCSWTrigger.h
